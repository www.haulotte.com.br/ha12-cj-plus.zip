Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:30:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:30:55 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{7F8E4BA2-9A6E-4F23-AF96-DCB0155FE96C}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:30:39 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:30:40 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:30:40 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA 12 CJ+, Construction_Aerial-Equipment_Haulotte_HA12CJ+_FR:HA 12 CJ+:4036224
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Working_Area, Metal - Haulotte - Red, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - White, Metal - Haulotte - Grey Dark
Type - Autre(Type) - Catégorie: Equipement spécialisé; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA12CJ+_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Nacelle articulée électrique; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 12 CJ+; Nom du type: HA 12 CJ+; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha12-cj-plus; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Angle de Levage Pendulaire: +63.5/-68.7°; Angle de Rotation Plateforme: +/-90°; Angle de Rotation Tourelle: 355°; Angle D'oscillation: na; Batteries: 48V-320Ah; Capacité Maximum: 200 kg/ 440.92 lb; Déport Arrière: 1215 mm/ 47,84 in; Déport Maximum: 7220 mm/284.25 in; Devers: 3°; Dimensions Plateforme: 1140x800 mm/44.8x31.5 in; Empattement: 1650 mm/ 64.96 in; Garde au Sol: 107 mm/ 4.21 in; Hauteur de Transport: 2700/106.3 in; Hauteur Plateforme: 9679 mm/381.06 in; Hauteur Repliée: 2000 mm/ 78.74 in; Hauteur Travail: 11679 mm/459.80 in; Largeur Hors Tout: 1200 mm/47.24 in; Longueur de Transport: 4200mm/ 165.35 in; Longueur Hors Tout: 5640 mm/222.05 in; Longueur Pendulaire: 2450 mm/ 96.46 in; Masse Machine (CE): 7110 kg / 15674.87 lg; Pente Maximum: 0.25; Pneus: 598x190mm/23.54x7.48 in; Point D'articulation: 4740 mm/ 186.61 in; Pression Max au Sol: 17.5 daN/Cm2; Rayon de Braquage Exterieur: 3650(+/-300)mm/78.74(+/-11.81); Rayon de Braquage Interieur: 2000(+/-300)mm/ 143.7(+/-11.81); Vitesse de Translation: 0.68-6 kmh/0.42-3.73mph
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA 12 CJ+
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A2: 75 deg; A4: 0 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA12CJ+_FR: HA 12 CJ+; Famille et type: Construction_Aerial-Equipment_Haulotte_HA12CJ+_FR: HA 12 CJ+; HRJA: 0 deg; ID du type: Construction_Aerial-Equipment_Haulotte_HA12CJ+_FR: HA 12 CJ+; L1: 3.894 m; L2: 3.7 m; R: 0 deg; Transport Position: no; Type: Construction_Aerial-Equipment_Haulotte_HA12CJ+_FR: HA 12 CJ+
Construction - Abaque de Travail: yes; Angle de Levage Flèche: 75 deg; Angle de Levage Pendulaire: 71 deg; Angle de Levage Pendulaire Horizontal: 0 deg; Angle de Rotation Tourelle: 0 deg; Hauteur Maxi Point D'articulation: 4.74 m; Rayon de Braquage Exterieur: yes; Rotation Panier: 0 deg; Sortie du Telescope: 3.7 m; Zone de Travail: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 66.487 m2; Volume: 21.4888 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
