Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:28:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:28:46 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{2A0446BB-0A7E-4238-8049-A1A8F58C275D}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:28:36 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:28:37 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:28:37 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA 12 CJ+, Construction_Aerial-Equipment_Haulotte_HA12CJ+_INT:HA 12 CJ+:4036220
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Working_Area, Metal - Haulotte - Red, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - White, Metal - Haulotte - Grey Dark
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 7110 kg / 15674.87 lg; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA12CJ+_INT
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Electric Articulating Boom; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 12 CJ+; Nom du type: HA 12 CJ+; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha12-cj-plus; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.co.uk
Type - Données(Type) - Batteries: 48V-320Ah; Drive Speed: 0.68-6 kmh/0.42-3.73mph; Gradeability: 0.25; Ground Clearance: 107 mm/ 4.21 in; Height - Storage / Transport: 2700/106.3 in; Height - Stowed: 2000 mm/ 78.74 in; Horizontal Outreach: 7220 mm/284.25 in; Jib Length: 2450 mm/ 96.46 in; Lenght - Storage/Transport: 4200mm/ 165.35 in; Length - Stowed: 5640 mm/222.05 in; Lift Capacity: 200 kg/ 440.92 lb; Max Ground Pressure of Wheel on Paved Ground: 17.5 daN/Cm2; Oscillating Angle: na; Platform Height: 9679 mm/381.06 in; Platform Rotation: +/-90°; Platform Size: 1140x800 mm/44.8x31.5 in; Tailswing: 1215 mm/ 47,84 in; Tilt: 3°; Tires: 598x190mm/23.54x7.48 in; Turnable Rotation: 355°; Turning Radius - Inside: 2000(+/-300)mm/ 143.7(+/-11.81); Turning Radius - Outside: 3650(+/-300)mm/78.74(+/-11.81); Up and Over Clearance: 4740 mm/ 186.61 in; Vertical Jib Rotation Angle: +63.5/-68.7°; Wheelbase: 1650 mm/ 64.96 in; Width: 1200 mm/47.24 in; Working Height: 11679 mm/459.80 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA 12 CJ+
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A2: 71 deg; A4: 0 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA12CJ+_INT: HA 12 CJ+; Famille et type: Construction_Aerial-Equipment_Haulotte_HA12CJ+_INT: HA 12 CJ+; HRJA: 0 deg; ID du type: Construction_Aerial-Equipment_Haulotte_HA12CJ+_INT: HA 12 CJ+; L1: 3.894 m; L2: 3.7 m; R: 0 deg; Transport Position: no; Type: Construction_Aerial-Equipment_Haulotte_HA12CJ+_INT: HA 12 CJ+
Construction - Boom Rotation Angle: 71 deg; Horizontal Jib Rotation Angle: 0 deg; Maximum Boom Articulation Point Height: 4.74 m; Platform Rotation Angle: 0 deg; Reach Diagram: yes; Telescopic Extend: 3.7 m; Turnable Rotation: 0 deg; Turning Radius: yes; Vertical Jib Rotation Angle: 64 deg; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 66.487 m2; Volume: 21.4888 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
